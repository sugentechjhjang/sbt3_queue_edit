# IAR project Backup (12) of iap_proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\FWLib\library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s_blot3_btl_ver000.bin
  ILINK.IlinkOutputFile: iap_proj.out
  ILINK.IlinkIcfFile: stm32_iap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../source/: common.c download.c main.c stm32f10x_it.c ymodem.c
  group ewarm
    ./: cortexm3_macro.s stm32f10x_vector.c
  group fwlib
    ../../../FWLib/library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_wwdg.c
